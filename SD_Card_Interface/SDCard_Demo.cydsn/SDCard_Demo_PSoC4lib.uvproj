# Keil uVision project SDCard_Demo_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: SDCard_Demo_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h SDCard_SPI.c SDCard.h SDCard_FS.c SDCard_SPI.h SDCard_FS.h SDCard_SPIM.c SDCard_SPIM.h SDCard_SPIM_SPI_UART.h SDCard_SPIM_SPI_UART.c SDCard_SPIM_SPI_UART_INT.c SDCard_SPIM_PM.c SDCard_SPIM_SPI.c SDCard_SPIM_BOOT.c SDCard_SPIM_SPI_BOOT.c SDCard_SPIM_PINS.h SDCard_SPIM_SPI_UART_PVT.h SDCard_SPIM_PVT.h SDCard_SD_Clock.c SDCard_SD_Clock.h SDCard_SD_PWR.c SDCard_SD_PWR.h SDCard_SD_PWR_aliases.h SDCard_SD_CS.c SDCard_SD_CS.h SDCard_SD_CS_aliases.h SDCard_SD_WP.c SDCard_SD_WP.h SDCard_SD_WP_aliases.h SDCard_SD_CD.c SDCard_SD_CD.h SDCard_SD_CD_aliases.h SDCard_SPIM_SCB_IRQ.c SDCard_SPIM_SCB_IRQ.h SDCard_SPIM_ss0_m.c SDCard_SPIM_ss0_m.h SDCard_SPIM_ss0_m_aliases.h SDCard_SPIM_mosi_m.c SDCard_SPIM_mosi_m.h SDCard_SPIM_mosi_m_aliases.h SDCard_SPIM_miso_m.c SDCard_SPIM_miso_m.h SDCard_SPIM_miso_m_aliases.h SDCard_SPIM_sclk_m.c SDCard_SPIM_sclk_m.h SDCard_SPIM_sclk_m_aliases.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: SDCard_Demo_PSoC4lib (library)
